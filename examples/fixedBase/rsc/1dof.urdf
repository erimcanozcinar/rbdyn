Commit message: some addition to kinematic calculations

File: examples/fixedBase/rsc/1dof.urdf (robot description, URDF)
Before this commit: robot 1dof, 4 links, 3 joints
Links:
- added link link3
Joints:
- added joint Joint3: type fixed, parent link2, child link3, origin xyz=0 0 0.250 rpy=0 0 0
